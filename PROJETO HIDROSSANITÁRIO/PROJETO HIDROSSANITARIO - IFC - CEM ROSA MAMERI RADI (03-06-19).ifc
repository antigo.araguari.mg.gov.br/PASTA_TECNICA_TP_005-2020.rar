Properties of the parts of a building model (IFC4)

# File
Description: IFC4
Time: 2019-05-08T17:02:32
Made in: IfcPlusPlus

# IfcBuildingStorey (2)
Name | LongName | Elevation (cm)
Térreo | Térreo | 45
1° Pavimento | 1° Pavimento | 395

# IfcBuildingElementProxy: Ar condicionado piso teto (3)
In: Térreo
Pset_Identificação_Elemento - Nome: 25mm; Descrição: Ar condicionado; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Ar condicionado piso teto
Name | Rede
2 x  | Esgoto
 | Pluvial

# IfcBuildingElementProxy: Ralo sifonado (4)
In: Térreo
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 100 x 53 x 40 mm; Descrição: Ralo sifonado; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Ralo sifonado

# IfcBuildingElementProxy: Taça 16250L, RCi1
In: Térreo
Pset_AltoQi_QiBuilder - EffectiveCapacity: 16250; NominalDepht: 500; NominalLenghtOrDiameter: 203
Pset_Identificação_Elemento - Rede: Água fria; Nome: 3/4"; Descrição: Taça 31350L; Aplicação: Reservatório cilíndrico; Classe: Reservatório cilíndrico; Tipo: Taça 16250L

# IfcFlowMeter: Alimentador Predial
In: Térreo
Type - PredefinedType: WATERMETER
Pset_Identificação_Elemento - Rede: Alimentação; Nome: Com tubo de PVC rígido-3/4"; Descrição: Alimentador Predial; Aplicação: Alimentador predial; Classe: PVC rígido soldável; Tipo: Alimentador Predial

# IfcInterceptor: Caixas de Gordura (3)
In: Térreo
Type - PredefinedType: OIL
Pset_Identificação_Elemento - Rede: Esgoto; Nome: CG PVC- 30x30 cm; Descrição: Caixas de Gordura; Aplicação: Caixa de passagem; Classe: Caixas de Passagem; Tipo: Caixas de Gordura

# IfcPipeFitting: Adaptador para bocal semi-circular s/ terminação (4)
In: 1° Pavimento
Type - PredefinedType: USERDEFINED
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 110 mm x 75 mm; Descrição: Adaptador para bocal semi-circular; Aplicação: Conexão; Classe: Calha metálica; Tipo: Adaptador para bocal semi-circular s/ terminação
Name
AP-1
AP-2
AP-3
AP-4

# IfcPipeFitting: Joelho 45 (23)
In: Térreo
Type - PredefinedType: BEND
Pset_Identificação_Elemento - Descrição: Joelho 45; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Joelho 45
Name | Rede | Nome
4 x  | Ventilação | 50 mm
5 x  | Esgoto | 100 mm
 | Ventilação | 75 mm
2 x  | Esgoto | 75 mm
5 x  | Esgoto | 40 mm
4 x  | Esgoto | 50 mm
 | Pluvial | 40 mm
 | Pluvial | 150 mm

# IfcPipeFitting: Joelho 45 soldável (5)
In: Térreo
Type - PredefinedType: BEND
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 25 mm; Descrição: Joelho 45 soldável; Aplicação: Conexão; Classe: PVC Drenagem; Tipo: Joelho 45 soldável

# IfcPipeFitting: Joelho 90
In: Térreo
Type - PredefinedType: BEND
Pset_Identificação_Elemento - Rede: Ventilação; Nome: 50 mm; Descrição: Joelho 90; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Joelho 90

# IfcPipeFitting: Joelho 90 soldável (51)
Type - PredefinedType: BEND
Pset_Identificação_Elemento - Descrição: Joelho 90 soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Joelho 90 soldável
Name | In | Rede | Nome
16 x  | Térreo | Água fria | 20 mm
 | Térreo | Água fria | 50 mm
6 x  | Térreo | Água fria | 25 mm
4 x  | Térreo | Alimentação | 25 mm
3 x  | Térreo | Água fria | 32 mm
3 x  | 1° Pavimento | Água fria | 50 mm
2 x  | 1° Pavimento | Água fria | 75 mm
2 x  | 1° Pavimento | Água fria | 60 mm
2 x  | 1° Pavimento | Água fria | 32 mm
11 x  | 1° Pavimento | Água fria | 20 mm
 | 1° Pavimento | Água fria | 25 mm

# IfcPipeFitting: Joelho 90- coluna (10)
In: Térreo
Type - PredefinedType: BEND
Pset_Identificação_Elemento - Descrição: Joelho 90- coluna; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Joelho 90- coluna
Name | Rede | Nome
4 x  | Pluvial | 75 mm
CV-2 | Ventilação | 75 mm
CV-3 | Ventilação | 75 mm
CV-4 | Ventilação | 50 mm
CV-5 | Ventilação | 50 mm
CV-6 | Ventilação | 50 mm
CV-7 | Ventilação | 75 mm

# IfcPipeFitting: Joelho de redução 90 soldável (10)
Type - PredefinedType: BEND
Pset_Identificação_Elemento - Rede: Água fria; Descrição: Joelho de redução 90 soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Joelho de redução 90 soldável
Name | In | Nome
3 x  | Térreo | 25 mm - 20 mm
3 x  | Térreo | 32 mm - 25 mm
2 x  | 1° Pavimento | 32 mm - 25 mm
2 x  | 1° Pavimento | 25 mm - 20 mm

# IfcPipeFitting: Junção dupla
In: Térreo
Type - PredefinedType: JUNCTION
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 75 mm; Descrição: Junção dupla; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Junção dupla

# IfcPipeFitting: Junção simples (38)
In: Térreo
Type - PredefinedType: JUNCTION
Pset_Identificação_Elemento - Descrição: Junção simples; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Junção simples
Name | Rede | Nome
3 x  | Esgoto | 100 mm - 50 mm
8 x  | Esgoto | 100 mm- 100 mm
3 x  | Ventilação | 75 mm 75 mm
3 x  | Ventilação | 75 mm - 50 mm
3 x  | Esgoto | 50 mm - 50 mm
4 x  | Esgoto | 100 mm - 75 mm
5 x  | Esgoto | 75 mm - 50 mm
4 x  | Esgoto | 40 mm x 40 mm
 | Pluvial | 100 mm - 75 mm
 | Pluvial | 100 mm - 50 mm
3 x  | Ventilação | 50 mm - 50 mm

# IfcPipeFitting: Junção simples c/ redução (5)
In: Térreo
Type - PredefinedType: JUNCTION
Pset_Identificação_Elemento - Descrição: Junção simples c/ redução; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Junção simples c/ redução
Name | Rede | Nome
 | Esgoto | 100 mm - 75 mm(75-75)
 | Esgoto | 75 mm - 50 mm(50-50)
2 x  | Pluvial | 100 mm - 75 mm(75-75)
 | Ventilação | 75 mm - 50 mm(50-50)

# IfcPipeFitting: Luva soldável (11)
In: Térreo
Type - PredefinedType: CONNECTOR
Pset_Identificação_Elemento - Rede: Água fria; Descrição: Luva soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Luva soldável
Name | Nome
 | 25 mm
AF-10 | 25 mm
AF-11 | 50 mm
AF-12 | 50 mm
AF-13 | 20 mm
AF-14 | 20 mm
AF-15 | 20 mm
AF-3 | 75 mm
AF-4 | 75 mm
AF-6 | 32 mm
AF-9 | 20 mm

# IfcPipeFitting: Ramais de Ventilação (17)
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_Identificação_Elemento - Rede: Ventilação; Aplicação: Ramal de ventilação; Classe: PVC Esgoto; Tipo: Ramais de Ventilação
Name | Nome | Descrição
5 x  | 50mm-50mm-135º | Ramais de Ventilação
4 x  | 100mm- 75mm-45º | Ramais de Ventilação
3 x  | 50mm-50mm-90º | Ramais de Ventilação
 | 75mm- 50mm-90º | Ramais de Ventilação
 | 75mm- 75mm-45º | Ramais de Ventilação
2 x  | 100mm - 50mm-90° | Ramais de ventilação
 | 50mm-50mm-180º | Ramais de Ventilação

# IfcPipeFitting: Ramais de ventilação em cruz (4)
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_Identificação_Elemento - Rede: Ventilação; Descrição: Ramais de Ventilação em Cruz; Aplicação: Ramal de ventilação; Classe: PVC Esgoto; Tipo: Ramais de ventilação em cruz
Name | Nome
3 x  | 50mm x 50mm - 225°
 | 100mm x 50mm - 135°

# IfcPipeFitting: Te 90 soldável (11)
Type - PredefinedType: JUNCTION
Pset_Identificação_Elemento - Rede: Água fria; Descrição: Te 90 soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Te 90 soldável
Name | In | Nome
9 x  | Térreo | 20 mm
 | Térreo | 25 mm
 | 1° Pavimento | 20 mm

# IfcPipeFitting: Te 90 soldável c/ redução lateral (6)
Type - PredefinedType: JUNCTION
Pset_Identificação_Elemento - Rede: Água fria; Descrição: Te 90 soldável c/ redução lateral; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Te 90 soldável c/ redução lateral
Name | In | Nome
2 x  | Térreo | 60 mm- 50mm
2 x  | Térreo | 25 mm- 20mm
 | 1° Pavimento | 50 mm- 32mm
 | 1° Pavimento | 60 mm- 25mm

# IfcPipeFitting: Te de redução 90 soldável (20)
In: Térreo
Type - PredefinedType: JUNCTION
Pset_Identificação_Elemento - Rede: Água fria; Descrição: Te de redução 90 soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Te de redução 90 soldável
Name | Nome
2 x  | 50 mm - 20 mm
2 x  | 50 mm - 25 mm
11 x  | 25 mm - 20 mm
 | 60 mm - 50 mm
4 x  | 32 mm - 25 mm

# IfcPipeFitting: Te de redução 90 soldável c/ redução lateral (14)
Type - PredefinedType: JUNCTION
Pset_Identificação_Elemento - Rede: Água fria; Descrição: Te de redução 90 soldável c/ redução lateral; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Te de redução 90 soldável c/ redução lateral
Name | In | Nome
2 x  | Térreo | 60 mm - 50 mm- 50mm
2 x  | Térreo | 60 mm - 50 mm- 32mm
2 x  | Térreo | 25 mm - 20 mm- 20mm
 | Térreo | 50 mm - 25 mm- 32mm
2 x  | Térreo | 75 mm - 60 mm- 60mm
 | Térreo | 32 mm - 25 mm- 20mm
 | 1° Pavimento | 85 mm - 75 mm- 75mm
 | 1° Pavimento | 50 mm - 32 mm- 40mm
 | 1° Pavimento | 40 mm - 32 mm- 25mm
 | 1° Pavimento | 60 mm - 50 mm- 50mm

# IfcPipeFitting: Te sanitário
In: Térreo
Type - PredefinedType: JUNCTION
Pset_Identificação_Elemento - Rede: Ventilação; Nome: 50 mm -50 mm; Descrição: Te sanitário; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Te sanitário

# IfcPipeFitting: Tomadas dágua- saídas curtas (9)
Type - PredefinedType: ENTRY
Pset_Identificação_Elemento - Descrição: Tomadas dágua- saídas curtas; Aplicação: Tomada d´água; Classe: PVC rígido soldável; Tipo: Tomadas dágua- saídas curtas
Name | In | Rede | Nome
 | Térreo | Água fria | 1/2"
 | Térreo | Água fria | 3/4"
 | Térreo | Alimentação | 3/4"
3 x  | 1° Pavimento | Água fria | 1/2"
2 x  | 1° Pavimento | Água fria | 2"
 | 1° Pavimento | Água fria | 1 1/2"

# IfcPipeFitting: Torneira bóia (4)
Type - PredefinedType: ENTRY
Pset_Identificação_Elemento - Descrição: Torneira de bóia; Aplicação: Tomada d´água; Classe: PVC rígido soldável; Tipo: Torneira bóia
Name | In | Rede | Nome
 | Térreo | Alimentação | 3/4"
3 x  | 1° Pavimento | Água fria | 1/2"

# IfcPipeSegment: Calha retangular (8)
In: 1° Pavimento
Type - PredefinedType: GUTTER
Pset_PipeSegmentTypeGutter - Slope: 1.000000
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 70 mm x 140 mm; Classe: Calha metálica; Tipo: Calha retangular; Aplicação: Calha retangular
Name | Comprimento
4 x  | 25
2 x  | 875.04
2 x  | 283.01

# IfcPipeSegment: Grelha retangular (7)
In: Térreo
Type - PredefinedType: GUTTER
Pset_PipeSegmentTypeGutter - Slope: 1.000000
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 150 mm x 150 mm; Classe: Grelha; Tipo: Grelha retangular; Aplicação: Calha retangular
Name | Comprimento
 | 3860.19
 | 4160.21
 | 837.54
 | 1002.55
2 x  | 885.04
 | 295.01

# IfcPipeSegment: Tubo PVC ponta-bolsa c/ virola
In: Térreo
Type - PredefinedType: RIGIDSEGMENT
Pset_PipeSegmentTypeCommon - NominalDiameter: ø4"; InnerDiameter: 100
Pset_AltoQi_QiBuilder - Inclinação (%): 1.000000; Comprimento: 213.32
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 100 mm - 4"; Classe: PVC Esgoto; Tipo: Tubo PVC ponta-bolsa c/ virola; Aplicação: Circular

# IfcPipeSegment: Tubo rígido c/ ponta lisa (203)
Type - PredefinedType: RIGIDSEGMENT
Pset_Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa; Aplicação: Circular
Name | In | NominalDiameter | InnerDiameter | Inclinação (%) | Comprimento | Rede | Nome
 | Térreo | ø4" | 100 | 1.000000 | 155.91 | Esgoto | 100 mm - 4"
 | Térreo | ø3" | 75 | 2.000000 | 39.08 | Esgoto | 75 mm - 3"
 | Térreo | ø4" | 100 | 2.000000 | 775 | Esgoto | 100 mm - 4"
 | Térreo | ø1 1/2" | 40 | 2.000000 | 298.56 | Esgoto | 40 mm
 | Térreo | ø1 1/2" | 40 | 2.000000 | 120.02 | Esgoto | 40 mm
 | Térreo | ø2" | 50 | 2.000000 | 21.21 | Esgoto | 50 mm - 2"
 | Térreo | ø1 1/2" | 40 | 2.000000 | 42.51 | Esgoto | 40 mm
 | Térreo | ø2" | 50 | 2.000000 | 115.62 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 40.78 | Esgoto | 50 mm - 2"
 | Térreo | ø4" | 100 | 2.000000 | 996.94 | Esgoto | 100 mm - 4"
 | Térreo | ø2" | 50 | 1.000000 | 81.84 | Esgoto | 50 mm - 2"
 | Térreo | ø4" | 100 | 1.000000 | 58.91 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 131.16 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 50.21 | Esgoto | 100 mm - 4"
 | Térreo | ø1 1/2" | 40 | 1.000000 | 99.2 | Esgoto | 40 mm
 | Térreo | ø2" | 50 | 1.000000 | 77.2 | Esgoto | 50 mm - 2"
 | Térreo | ø1 1/2" | 40 | 1.000000 | 70.45 | Esgoto | 40 mm
 | Térreo | ø3" | 75 | 1.000000 | 271.79 | Esgoto | 75 mm - 3"
 | Térreo | ø2" | 50 | 1.000000 | 15.11 | Esgoto | 50 mm - 2"
 | Térreo | ø1 1/2" | 40 | 1.000000 | 17.75 | Esgoto | 40 mm
 | Térreo | ø2" | 50 | 1.000000 | 11.35 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 64.85 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 146.38 | Esgoto | 50 mm - 2"
 | Térreo | ø3" | 75 | 1.000000 | 270.67 | Esgoto | 75 mm - 3"
 | Térreo | ø3" | 75 | 1.000000 | 87.43 | Esgoto | 75 mm - 3"
 | Térreo | ø2" | 50 | 1.000000 | 41.5 | Esgoto | 50 mm - 2"
 | Térreo | ø4" | 100 | 1.000000 | 2000 | Esgoto | 100 mm - 4"
 | Térreo | ø1 1/2" | 40 | 1.000000 | -375.81 | Esgoto | 40 mm
 | Térreo | ø3" | 75 | 1.000000 | 162.84 | Esgoto | 75 mm - 3"
 | Térreo | ø4" | 100 | 1.000000 | 264.17 | Esgoto | 100 mm - 4"
 | Térreo | ø3" | 75 | 1.000000 | 50.7 | Esgoto | 75 mm - 3"
 | Térreo | ø3" | 75 | 1.000000 | 43.5 | Esgoto | 75 mm - 3"
2 x  | Térreo | ø3" | 75 | 1.000000 | 75.46 | Esgoto | 75 mm - 3"
 | Térreo | ø4" | 100 | 1.000000 | 69 | Esgoto | 100 mm - 4"
2 x  | Térreo | ø4" | 100 | 1.000000 | 60.86 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 60.08 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 708.75 | Esgoto | 100 mm - 4"
2 x  | Térreo | ø3" | 75 | 1.000000 | 135.73 | Esgoto | 75 mm - 3"
 | Térreo | ø4" | 100 | 1.000000 | 7.4 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 43.1 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 87 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 66.5 | Esgoto | 100 mm - 4"
3 x  | Térreo | ø4" | 100 | 1.000000 | 76 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 45.57 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 622.09 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 969.29 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 200 | Esgoto | 100 mm - 4"
 | Térreo | ø2" | 50 | 2.000000 | 114.37 | Esgoto | 50 mm - 2"
 | Térreo | ø4" | 100 | 2.000000 | 66.02 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 2.000000 | 60.87 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 22.91 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 45.15 | Esgoto | 100 mm - 4"
 | Térreo | ø3" | 75 | 1.000000 | 58.8 | Esgoto | 75 mm - 3"
 | Térreo | ø3" | 75 | 1.000000 | 51.46 | Ventilação | 75 mm - 3"
 | Térreo | ø3" | 75 | 1.000000 | 24.82 | Ventilação | 75 mm - 3"
 | Térreo | ø3" | 75 | 1.000000 | 156.01 | Ventilação | 75 mm - 3"
 | Térreo | ø4" | 100 | 1.000000 | 89.06 | Esgoto | 100 mm - 4"
 | Térreo | ø3" | 75 | 1.000000 | 178.66 | Ventilação | 75 mm - 3"
 | Térreo | ø3" | 75 | 19.740000 | 49.59 | Ventilação | 75 mm - 3"
 | Térreo | ø3" | 75 | 1.000000 | 2.89 | Ventilação | 75 mm - 3"
2 x  | Térreo | ø3" | 75 | 1.000000 | 54.7 | Ventilação | 75 mm - 3"
 | Térreo | ø3" | 75 | 1.000000 | 143.09 | Ventilação | 75 mm - 3"
 | Térreo | ø2" | 50 | 2.000000 | 603.28 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 215.53 | Ventilação | 50 mm - 2"
 | Térreo | ø3" | 75 | 19.740000 | 53.18 | Ventilação | 75 mm - 3"
 | Térreo | ø2" | 50 | 14.330000 | 81.87 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 62.7 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 65.75 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 5.1 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 71.89 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 16.11 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 39.57 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 320.51 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 57.81 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 70.63 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 79.53 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 65.73 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 342.89 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 20.2 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 24.32 | Ventilação | 50 mm - 2"
 | Térreo | ø1 1/2" | 40 | 1.000000 | 95.31 | Esgoto | 40 mm
 | Térreo | ø1 1/2" | 40 | 1.000000 | 20.41 | Esgoto | 40 mm
 | Térreo | ø4" | 100 | 1.000000 | 61.21 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 50.81 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 45.7 | Esgoto | 100 mm - 4"
 | Térreo | ø2" | 50 | 1.000000 | 14.1 | Esgoto | 50 mm - 2"
2 x  | Térreo | ø4" | 100 | 1.000000 | 31.31 | Esgoto | 100 mm - 4"
 | Térreo | ø2" | 50 | 15.340000 | 98.67 | Ventilação | 50 mm - 2"
 | Térreo | ø4" | 100 | 1.000000 | 49.16 | Esgoto | 100 mm - 4"
 | Térreo | ø1 1/2" | 40 | 1.000000 | 22.75 | Esgoto | 40 mm
 | Térreo | ø1 1/2" | 40 | 1.000000 | 93.65 | Esgoto | 40 mm
 | Térreo | ø4" | 100 | 1.000000 | 47.35 | Esgoto | 100 mm - 4"
 | Térreo | ø2" | 50 | 1.000000 | 11.76 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 77.86 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 7.3 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 54.29 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 98.77 | Ventilação | 50 mm - 2"
 | Térreo | ø1 1/2" | 40 | 1.000000 | -354.64 | Esgoto | 40 mm
 | Térreo | ø3" | 75 | 2.000000 | 190.1 | Esgoto | 75 mm - 3"
 | Térreo | ø2" | 50 | 2.000000 | 13.79 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 103.58 | Esgoto | 50 mm - 2"
2 x  | Térreo | ø2" | 50 | 2.000000 | 64.15 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 18.91 | Esgoto | 50 mm - 2"
 | Térreo | ø3" | 75 | 2.000000 | 22.73 | Esgoto | 75 mm - 3"
 | Térreo | ø2" | 50 | 2.000000 | 112.18 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 151.29 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 288.01 | Ventilação | 50 mm - 2"
 | Térreo | ø3" | 75 | 2.000000 | 206.58 | Esgoto | 75 mm - 3"
 | Térreo | ø2" | 50 | 1.000000 | 205.06 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 34.07 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 157.68 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 27.37 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 260.01 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 105.26 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 259.3 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 42.56 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 93.86 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 22.26 | Ventilação | 50 mm - 2"
 | Térreo | ø3" | 75 | 1.000000 | 39.4 | Ventilação | 75 mm - 3"
4 x  | Térreo | ø3" | 75 | 1.000000 | 58.5 | Pluvial | 75 mm - 3"
 | Térreo | ø6" | 150 | 1.000000 | 1012.5 | Pluvial | 150 mm- 6"
 | Térreo | ø6" | 150 | 1.000000 | 143.84 | Pluvial | 150 mm- 6"
 | Térreo | ø6" | 150 | 1.000000 | 145.14 | Pluvial | 150 mm- 6"
 | Térreo | ø6" | 150 | 1.000000 | 420.99 | Pluvial | 150 mm- 6"
 | Térreo | ø6" | 150 | 1.000000 | 707.67 | Pluvial | 150 mm- 6"
 | Térreo | ø1 1/2" | 40 | 1.000000 | 761.76 | Pluvial | 40 mm
 | Térreo | ø1 1/2" | 40 | 1.000000 | 158.31 | Pluvial | 40 mm
 | Térreo | ø4" | 100 | 1.000000 | 157.26 | Pluvial | 100 mm - 4"
 | Térreo | ø3" | 75 | 1.000000 | 148.13 | Pluvial | 75 mm - 3"
 | Térreo | ø3" | 75 | 1.000000 | 990.36 | Pluvial | 75 mm - 3"
 | Térreo | ø4" | 100 | 1.000000 | 158.42 | Pluvial | 100 mm - 4"
 | Térreo | ø3" | 75 | 1.000000 | 148.32 | Pluvial | 75 mm - 3"
 | Térreo | ø3" | 75 | 1.000000 | 990.55 | Pluvial | 75 mm - 3"
 | Térreo | ø4" | 100 | 3.570000 | 500.03 | Pluvial | 100 mm - 4"
 | Térreo | ø2" | 50 | 1.000000 | 149.54 | Pluvial | 50 mm - 2"
 | Térreo | ø4" | 100 | 1.000000 | 958.75 | Pluvial | 100 mm - 4"
 | Térreo | ø4" | 100 | 1.000000 | 333.32 | Pluvial | 100 mm - 4"
 | Térreo | ø3" | 75 | 1.000000 | 149.38 | Pluvial | 75 mm - 3"
 | Térreo | ø4" | 100 | 1.000000 | 1122.25 | Pluvial | 100 mm - 4"
2 x  | Térreo | ø1 1/2" | 40 | 2.000000 | -307.7 | Esgoto | 40 mm
2 x  | Térreo | ø1 1/2" | 40 | 2.000000 | 62.51 | Esgoto | 40 mm
4 x  | Térreo | ø1 1/2" | 40 | 2.000000 | 21.22 | Esgoto | 40 mm
4 x  | Térreo | ø1 1/2" | 40 | 2.000000 | 13.72 | Esgoto | 40 mm
2 x  | Térreo | ø2" | 50 | 2.000000 | 20.71 | Esgoto | 50 mm - 2"
2 x  | Térreo | ø1 1/2" | 40 | 2.000000 | 69.21 | Esgoto | 40 mm
2 x  | Térreo | ø1 1/2" | 40 | 2.000000 | 20.42 | Esgoto | 40 mm
2 x  | Térreo | ø3" | 75 | 2.000000 | 23.89 | Esgoto | 75 mm - 3"
2 x  | Térreo | ø3" | 75 | 2.000000 | 16.31 | Esgoto | 75 mm - 3"
2 x  | Térreo | ø1 1/2" | 40 | 2.000000 | 63.22 | Esgoto | 40 mm
 | Térreo | ø2" | 50 | 2.000000 | 178.61 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 8.64 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 252.84 | Ventilação | 50 mm - 2"
 | Térreo | ø3" | 75 | 1.000000 | 24.93 | Ventilação | 75 mm - 3"
 | Térreo | ø3" | 75 | 2.000000 | 34.84 | Esgoto | 75 mm - 3"
 | Térreo | ø4" | 100 | 2.000000 | 162.83 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 2.000000 | 65.54 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 2.000000 | 32.09 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 2.000000 | 41.41 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 2.000000 | 26.79 | Esgoto | 100 mm - 4"
 | Térreo | ø2" | 50 | 2.000000 | 174.41 | Esgoto | 50 mm - 2"
 | Térreo | ø4" | 100 | 2.000000 | 8.81 | Esgoto | 100 mm - 4"
 | Térreo | ø4" | 100 | 2.000000 | 106.94 | Esgoto | 100 mm - 4"
 | Térreo | ø3" | 75 | 1.000000 | 47.97 | Ventilação | 75 mm - 3"
 | Térreo | ø4" | 100 | 2.000000 | 43.93 | Esgoto | 100 mm - 4"
 | Térreo | ø2" | 50 | 1.000000 | 47.37 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 201.81 | Ventilação | 50 mm - 2"
 | Térreo | ø2" | 50 | 2.000000 | 18.54 | Esgoto | 50 mm - 2"
 | Térreo | ø2" | 50 | 1.000000 | 28.5 | Ventilação | 50 mm - 2"
 | 1° Pavimento | ø3" | 75 | 1.000000 | 408.97 | Ventilação | 75 mm - 3"
 | 1° Pavimento | ø2" | 50 | 1.000000 | 369.15 | Ventilação | 50 mm - 2"
 | 1° Pavimento | ø2" | 50 | 1.000000 | 386.46 | Ventilação | 50 mm - 2"
 | 1° Pavimento | ø2" | 50 | 1.000000 | 396.51 | Ventilação | 50 mm - 2"
 | 1° Pavimento | ø3" | 75 | 1.000000 | 386.11 | Ventilação | 75 mm - 3"
 | 1° Pavimento | ø3" | 75 | 1.000000 | 400.52 | Ventilação | 75 mm - 3"
2 x  | 1° Pavimento | ø3" | 75 | 1.000000 | 301.85 | Pluvial | 75 mm - 3"
2 x  | 1° Pavimento | ø3" | 75 | 1.000000 | 307.77 | Pluvial | 75 mm - 3"

# IfcPipeSegment: Tubos (222)
Type - PredefinedType: RIGIDSEGMENT
Pset_Identificação_Elemento - Classe: PVC rígido soldável; Tipo: Tubos; Aplicação: Circular
Name | In | NominalDiameter | InnerDiameter | Comprimento | Rede | Nome
8 x  | Térreo | ø1 1/2" | 40 | -5 | Água fria | 50 mm
2 x  | Térreo | ø1 1/2" | 40 | 28.62 | Água fria | 50 mm
 | Térreo | ø2" | 50 | 56.85 | Água fria | 60 mm
11 x  | Térreo | ø1/2" | 15 | 87.05 | Água fria | 20 mm
5 x  | Térreo | ø3/4" | 20 | 65.7 | Água fria | 25 mm
2 x  | Térreo | ø1" | 25 | 44.8 | Água fria | 32 mm
2 x  | Térreo | ø3/4" | 20 | 40.25 | Água fria | 25 mm
2 x  | Térreo | ø1" | 25 | 327.35 | Água fria | 32 mm
6 x  | Térreo | ø1/2" | 15 | 88.1 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 67.05 | Água fria | 20 mm
3 x  | Térreo | ø1 1/2" | 40 | 28.61 | Água fria | 50 mm
 | Térreo | ø3/4" | 20 | 17.3 | Água fria | 25 mm
3 x  | Térreo | ø3/4" | 20 | 17.7 | Água fria | 25 mm
 | Térreo | ø2" | 50 | 84 | Água fria | 60 mm
 | Térreo | ø1 1/2" | 40 | 101.36 | Água fria | 50 mm
 | Térreo | ø1" | 25 | 52.75 | Água fria | 32 mm
 | Térreo | ø3/4" | 20 | 17.4 | Água fria | 25 mm
 | Térreo | ø1" | 25 | 54.7 | Água fria | 32 mm
 | Térreo | ø1" | 25 | 56.9 | Água fria | 32 mm
 | Térreo | ø1" | 25 | 29.15 | Água fria | 32 mm
 | Térreo | ø3/4" | 20 | 31.45 | Água fria | 25 mm
 | Térreo | ø1" | 25 | 4.45 | Água fria | 32 mm
 | Térreo | ø1" | 25 | 100.19 | Água fria | 32 mm
2 x  | Térreo | ø2" | 50 | 97.65 | Água fria | 60 mm
2 x  | Térreo | ø2 1/2" | 60 | 159.97 | Água fria | 75 mm
 | Térreo | ø2" | 50 | 58.65 | Água fria | 60 mm
2 x  | Térreo | ø2 1/2" | 60 | 15.62 | Água fria | 75 mm
5 x  | Térreo | ø3/4" | 20 | 18.75 | Água fria | 25 mm
2 x  | Térreo | ø3/4" | 20 | 70.7 | Água fria | 25 mm
 | Térreo | ø1" | 25 | 166.48 | Água fria | 32 mm
 | Térreo | ø3/4" | 20 | 122.31 | Água fria | 25 mm
 | Térreo | ø1/2" | 15 | 37.05 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 260.75 | Água fria | 25 mm
 | Térreo | ø1/2" | 15 | 25.04 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 203.2 | Água fria | 20 mm
3 x  | Térreo | ø1/2" | 15 | 38 | Água fria | 20 mm
2 x  | Térreo | ø1/2" | 15 | 166.87 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 166.65 | Água fria | 25 mm
2 x  | Térreo | ø1/2" | 15 | 88 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 118.5 | Água fria | 25 mm
 | Térreo | ø3/4" | 20 | 45.15 | Água fria | 25 mm
 | Térreo | ø3/4" | 20 | 8.9 | Água fria | 25 mm
 | Térreo | ø1/2" | 15 | 257.6 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 32.25 | Água fria | 25 mm
2 x  | Térreo | ø1 1/2" | 40 | 5 | Água fria | 50 mm
2 x  | Térreo | ø1 1/2" | 40 | 21.01 | Água fria | 50 mm
2 x  | Térreo | ø1 1/2" | 40 | 165.86 | Água fria | 50 mm
2 x  | Térreo | ø1 1/2" | 40 | 0.71 | Água fria | 50 mm
 | Térreo | ø3/4" | 20 | 75.4 | Água fria | 25 mm
2 x  | Térreo | ø1/2" | 15 | 4.45 | Água fria | 20 mm
2 x  | Térreo | ø1/2" | 15 | 86.1 | Água fria | 20 mm
2 x  | Térreo | ø1 1/2" | 40 | 20.55 | Água fria | 50 mm
2 x  | Térreo | ø1/2" | 15 | 66.6 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 85.4 | Água fria | 25 mm
 | Térreo | ø1/2" | 15 | 83.1 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 26.07 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 198.08 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 81.65 | Água fria | 25 mm
2 x  | Térreo | ø3/4" | 20 | 45.7 | Água fria | 25 mm
 | Térreo | ø1/2" | 15 | 75.05 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 133.3 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 38.1 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 48.24 | Água fria | 25 mm
 | Térreo | ø1" | 25 | 24.18 | Água fria | 32 mm
 | Térreo | ø3/4" | 20 | 24.75 | Água fria | 25 mm
 | Térreo | ø1/2" | 15 | 116.87 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 65.15 | Água fria | 25 mm
 | Térreo | ø3/4" | 20 | 44.55 | Água fria | 25 mm
 | Térreo | ø3/4" | 20 | 213.9 | Água fria | 25 mm
 | Térreo | ø1/2" | 15 | 33.5 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 97.25 | Água fria | 25 mm
 | Térreo | ø3/4" | 20 | 24.55 | Água fria | 25 mm
 | Térreo | ø3/4" | 20 | 295.8 | Alimentação | 25 mm
 | Térreo | ø3/4" | 20 | 72.3 | Alimentação | 25 mm
 | Térreo | ø3/4" | 20 | 485.8 | Alimentação | 25 mm
 | Térreo | ø3/4" | 20 | 7.9 | Alimentação | 25 mm
 | Térreo | ø3/4" | 20 | 10 | Água fria | 25 mm
 | Térreo | ø1/2" | 15 | 559.1 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 55.97 | Água fria | 20 mm
2 x  | Térreo | ø1/2" | 15 | 399.1 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 48.2 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 228.3 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 35.97 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 297.9 | Água fria | 25 mm
 | Térreo | ø3/4" | 20 | 29.55 | Água fria | 25 mm
 | Térreo | ø3/4" | 20 | 86.65 | Água fria | 25 mm
 | Térreo | ø1/2" | 15 | 50.75 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 277.54 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 1895.7 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 206.95 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 47.05 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 48.39 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 48.4 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 50.82 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 48.3 | Água fria | 20 mm
3 x  | Térreo | ø1/2" | 15 | 89.1 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 330.75 | Água fria | 25 mm
 | Térreo | ø1/2" | 15 | 88.15 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 33.3 | Água fria | 20 mm
 | Térreo | ø1/2" | 15 | 23.3 | Água fria | 20 mm
 | Térreo | ø3/4" | 20 | 187.2 | Alimentação | 25 mm
 | Térreo | ø3/4" | 20 | 604.44 | Alimentação | 25 mm
 | Térreo | ø1 1/2" | 40 | 32.62 | Água fria | 50 mm
 | Térreo | ø1 1/2" | 40 | 81.3 | Água fria | 50 mm
 | Térreo | ø2" | 50 | 79.7 | Água fria | 60 mm
 | Térreo | ø2" | 50 | 78.4 | Água fria | 60 mm
2 x  | Térreo | ø1 1/2" | 40 | 31.02 | Água fria | 50 mm
 | 1° Pavimento | ø1/2" | 15 | 75.95 | Água fria | 20 mm
 | 1° Pavimento | ø3/4" | 20 | 32.21 | Água fria | 25 mm
 | 1° Pavimento | ø1" | 25 | 317.38 | Água fria | 32 mm
 | 1° Pavimento | ø1" | 25 | 180 | Água fria | 32 mm
 | 1° Pavimento | ø1 1/2" | 40 | 76.9 | Água fria | 50 mm
 | 1° Pavimento | ø2" | 50 | 157.48 | Água fria | 60 mm
 | 1° Pavimento | ø3/4" | 20 | 143.8 | Água fria | 25 mm
2 x  | 1° Pavimento | ø1/2" | 15 | 41.5 | Água fria | 20 mm
2 x  | 1° Pavimento | ø1/2" | 15 | 28.37 | Água fria | 20 mm
 | 1° Pavimento | ø1 1/2" | 40 | 13.06 | Água fria | 50 mm
 | 1° Pavimento | ø1/2" | 15 | 36.5 | Água fria | 20 mm
 | 1° Pavimento | ø1/2" | 15 | 23.37 | Água fria | 20 mm
 | 1° Pavimento | ø2 1/2" | 60 | 494 | Água fria | 75 mm
 | 1° Pavimento | ø1/2" | 15 | 648.35 | Água fria | 20 mm
 | 1° Pavimento | ø1/2" | 15 | 1381.8 | Água fria | 20 mm
3 x  | 1° Pavimento | ø1/2" | 15 | 178.2 | Água fria | 20 mm
 | 1° Pavimento | ø1/2" | 15 | 5.1 | Água fria | 20 mm
 | 1° Pavimento | ø1/2" | 15 | 1173.3 | Água fria | 20 mm
4 x  | 1° Pavimento | ø1/2" | 15 | 9.1 | Água fria | 20 mm
2 x  | 1° Pavimento | ø1/2" | 15 | 8.35 | Água fria | 20 mm
 | 1° Pavimento | ø1 1/2" | 40 | 4.3 | Água fria | 50 mm
 | 1° Pavimento | ø1 1/2" | 40 | -0.4 | Água fria | 50 mm
 | 1° Pavimento | ø1 1/2" | 40 | 7.3 | Água fria | 50 mm
 | 1° Pavimento | ø1 1/2" | 40 | 3.3 | Água fria | 50 mm
2 x  | 1° Pavimento | ø2 1/2" | 60 | 5.3 | Água fria | 75 mm
 | 1° Pavimento | ø1" | 25 | 7.8 | Água fria | 32 mm
 | 1° Pavimento | ø3/4" | 20 | 7.4 | Água fria | 25 mm
 | 1° Pavimento | ø3/4" | 20 | 7.9 | Água fria | 25 mm
 | 1° Pavimento | ø2" | 50 | 218.95 | Água fria | 60 mm
 | 1° Pavimento | ø2" | 50 | 333.09 | Água fria | 60 mm
 | 1° Pavimento | ø1 1/2" | 40 | 87.3 | Água fria | 50 mm
 | 1° Pavimento | ø1 1/2" | 40 | 13.16 | Água fria | 50 mm
3 x  | 1° Pavimento | ø1/2" | 15 | 99.1 | Água fria | 20 mm
3 x  | 1° Pavimento | ø1/2" | 15 | 94.47 | Água fria | 20 mm
 | 1° Pavimento | ø2" | 50 | 34.94 | Água fria | 60 mm
2 x  | 1° Pavimento | ø2" | 50 | 86.8 | Água fria | 60 mm
 | 1° Pavimento | ø2" | 50 | 20.05 | Água fria | 60 mm
 | 1° Pavimento | ø3/4" | 20 | 32.81 | Água fria | 25 mm
 | 1° Pavimento | ø2 1/2" | 60 | 156.5 | Água fria | 75 mm
 | 1° Pavimento | ø1" | 25 | 340.6 | Água fria | 32 mm
 | 1° Pavimento | ø1" | 25 | 507.49 | Água fria | 32 mm
 | 1° Pavimento | ø1 1/4" | 32 | 198.65 | Água fria | 40 mm

# IfcPipeSegment: Tubos PVC rígido Soldável (8)
In: Térreo
Type - PredefinedType: RIGIDSEGMENT
Pset_PipeSegmentTypeCommon - NominalDiameter: ø3/4"; InnerDiameter: 20
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 25 mm; Classe: PVC Drenagem; Tipo: Tubos PVC rígido Soldável; Aplicação: Circular
Name | Inclinação (%) | Comprimento
2 x  | 1.000000 | 47.9
 | 1.000000 | 365.82
 | 1.000000 | 140.62
 | 1.000000 | 814.49
 | 1.000000 | 148.62
 | 1.000000 | 199.02
 | 5.690000 | 443.31

# IfcSanitaryTerminal: Bebedouro (3)
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 40mm; Descrição: Bebedouro; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Bebedouro

# IfcSanitaryTerminal: Bebedouro com joelho de 90º (3)
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.1
Pset_Identificação_Elemento - Rede: Água fria; Descrição: Bebedouro com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Bebedouro com joelho de 90º
Name | Nome
2 x  | 20 mm - 1/2"
 | 25 mm - 1/2"

# IfcSanitaryTerminal: Chuveiro (2)
In: Térreo
Type - PredefinedType: SHOWER
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.1
Pset_Identificação_Elemento - Rede: Água fria; Nome: 20mm x 1/2"; Descrição: Chuveiro; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Chuveiro

# IfcSanitaryTerminal: Chuveiro Residencial (4)
In: Térreo
Type - PredefinedType: SHOWER
Pset_Identificação_Elemento - Rede: Esgoto; Aplicação: Caixa sifonada; Classe: PVC Esgoto; Tipo: Chuveiro Residencial
Name | Nome | Descrição
2 x  | CS - 150x185x75 | Caixa sifonada
2 x  | CS - 150x150x50 | Caixa sifonada (ralo)

# IfcSanitaryTerminal: Escovario de Calha por metro- DN 50mm
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 50mm; Descrição: Escovario de Calha por metro- DN 50mm; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Escovario de Calha por metro- DN 50mm

# IfcSanitaryTerminal: Lavatório Residencial com sifão (13)
In: Térreo
Type - PredefinedType: WASHHANDBASIN
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 40mm; Descrição: Lavatório Residencial com sifão; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Lavatório Residencial com sifão

# IfcSanitaryTerminal: Lavatório com joelho de 90º (18)
In: Térreo
Type - PredefinedType: WASHHANDBASIN
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.15
Pset_Identificação_Elemento - Rede: Água fria; Nome: 20 mm - 1/2"; Descrição: Lavatório com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Lavatório com joelho de 90º

# IfcSanitaryTerminal: Mictório c/sifão,c/válvula de descarga,com joelho de 90º (5)
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.5
Pset_Identificação_Elemento - Rede: Água fria; Nome: 25 mm - 3/4"; Descrição: Mictório c/sifão,c/válvula de descarga,com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Mictório c/sifão,c/válvula de descarga,com joelho de 90º

# IfcSanitaryTerminal: Mictório de Válvula de Descarga- DN 75mm (5)
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 75mm; Descrição: Mictório de Válvula de Descarga- DN 75mm; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Mictório de Válvula de Descarga- DN 75mm

# IfcSanitaryTerminal: Pia de Cozinha Industrial - Lavagem de panelas com Sifão (3)
In: Térreo
Type - PredefinedType: SINK
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 50mm; Descrição: Pia de Cozinha Industrial - Lavagem de panelas com Sifão; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Pia de Cozinha Industrial - Lavagem de panelas com Sifão

# IfcSanitaryTerminal: Pia de Cozinha Industrial - Preparação com Sifão
In: Térreo
Type - PredefinedType: SINK
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 50mm; Descrição: Pia de Cozinha Industrial - Preparação com Sifão; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Pia de Cozinha Industrial - Preparação com Sifão

# IfcSanitaryTerminal: Pia de Cozinha Residencial com Sifão 50mm (2)
In: Térreo
Type - PredefinedType: SINK
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 50mm; Descrição: Pia de Cozinha Residencial com Sifão 50mm; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Pia de Cozinha Residencial com Sifão 50mm

# IfcSanitaryTerminal: Pia de cozinha com joelho de 90º (5)
In: Térreo
Type - PredefinedType: SINK
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.25
Pset_Identificação_Elemento - Rede: Água fria; Nome: 20 mm - 1/2"; Descrição: Pia de cozinha com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Pia de cozinha com joelho de 90º

# IfcSanitaryTerminal: Pia de despejo com joelho de 90º
In: Térreo
Type - PredefinedType: SINK
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.25
Pset_Identificação_Elemento - Rede: Água fria; Nome: 25 mm - 3/4"; Descrição: Pia de despejo com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Pia de despejo com joelho de 90º

# IfcSanitaryTerminal: Saídas livres (8)
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0
Pset_Identificação_Elemento - Rede: Água fria; Descrição: Saídas livres; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Saídas livres
Name | In | Nome
2 x  | Térreo | 25 mm
6 x  | 1° Pavimento | 20 mm

# IfcSanitaryTerminal: Tanque de Lavar Roupas DN 40mm
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 40mm; Descrição: Tanque de Lavar Roupas DN 40mm; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Tanque de Lavar Roupas DN 40mm

# IfcSanitaryTerminal: Tanque de Lavar Roupas DN 50mm
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 50mm; Descrição: Tanque de Lavar Roupas DN 50mm; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Tanque de Lavar Roupas DN 50mm

# IfcSanitaryTerminal: Tanque de lavar com joelho de 90º (2)
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.25
Pset_Identificação_Elemento - Rede: Água fria; Nome: 25 mm - 3/4"; Descrição: Tanque de lavar com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Tanque de lavar com joelho de 90º

# IfcSanitaryTerminal: Torneira de Jardim com joelho 90° (6)
In: Térreo
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.3
Pset_Identificação_Elemento - Rede: Água fria; Nome: 20 mm x 1/2"; Descrição: Torneira de Jardim; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Torneira de Jardim com joelho 90°

# IfcSanitaryTerminal: Vaso Sanitário c/ J90º (10)
In: Térreo
Type - PredefinedType: WCSEAT
Pset_Identificação_Elemento - Rede: Esgoto; Nome: 100 mm; Descrição: Vaso Sanitário c/ J90º; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Vaso Sanitário c/ J90º

# IfcSanitaryTerminal: Vaso Sanitário com válvula de descarga (10)
In: Térreo
Type - PredefinedType: WCSEAT
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 1.7
Pset_Identificação_Elemento - Rede: Água fria; Nome: 1 1/2"; Descrição: Vaso Sanitário com válvula de descarga; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Vaso Sanitário com válvula de descarga

# IfcTank: Polietileno - 1500 L (3)
In: 1° Pavimento
Type - PredefinedType: STORAGE
Pset_TankTypeCommon - NominalCapacity: 1500; NominalDepht: 105; NominalLenghtOrDiameter: 177
Pset_Identificação_Elemento - Rede: Água fria; Descrição: Polietileno - 1500 L; Aplicação: Reservatório cilíndrico; Classe: Reservatório cilíndrico; Tipo: Polietileno - 1500 L
Name | Nome
RCi1 | 1.1/2"
RCi2 | 2.1/2"
RCi3 | 2.1/2"

# IfcValve: Registro bruto gaveta ABNT c/PVC soldável (16)
Type - PredefinedType: ISOLATING
Pset_Identificação_Elemento - Rede: Água fria; Descrição: Registro bruto gaveta ABNT c/PVC soldável; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Registro bruto gaveta ABNT c/PVC soldável
Name | In | Nome
3 x  | Térreo | 1/2"
4 x  | Térreo | 3/4"
2 x  | Térreo | 1.1/2"
 | Térreo | 1"
3 x  | 1° Pavimento | 1/2"
2 x  | 1° Pavimento | 2"
 | 1° Pavimento | 1.1/2"

# IfcValve: Registro bruto gaveta Industrial c/PVC soldável (2)
In: Térreo
Type - PredefinedType: ISOLATING
Pset_Identificação_Elemento - Rede: Água fria; Nome: 2.1/2"; Descrição: Registro bruto gaveta Industrial c/PVC soldável; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Registro bruto gaveta Industrial c/PVC soldável

# IfcValve: Registro de Pressão com PVC soldável (2)
In: Térreo
Type - PredefinedType: REGULATING
Pset_Identificação_Elemento - Rede: Água fria; Nome: 20 mm - 1/2"; Descrição: Registro de Pressão com PVC soldável; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Registro de Pressão com PVC soldável

# IfcValve: Valvula de descarga c/PVC soldável (10)
In: Térreo
Type - PredefinedType: FLUSHING
Pset_Identificação_Elemento - Rede: Água fria; Nome: 1.1/2"; Descrição: Valvula de descarga c/PVC soldável; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Valvula de descarga c/PVC soldável

# IfcValve: Válvula de descarga para mictório (5)
In: Térreo
Type - PredefinedType: FLUSHING
Pset_Identificação_Elemento - Rede: Água fria; Nome: 3/4"; Descrição: Válvula de descarga p/ mictório; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Válvula de descarga para mictório

# IfcWasteTerminal: Caixa Sifonada (8)
In: Térreo
Type - PredefinedType: FLOORWASTE
Pset_Identificação_Elemento - Rede: Esgoto; Descrição: Caixa Sifonada; Aplicação: Caixa sifonada; Classe: PVC Esgoto; Tipo: Caixa Sifonada
Name | Nome
4 x  | 150x150x50
 | 150x150x50R
3 x  | 100x100x50

# IfcWasteTerminal: Caixa de areia pluvial simples (6)
In: Térreo
Type - PredefinedType: GULLYSUMP
Pset_Identificação_Elemento - Rede: Pluvial; Nome: CA-60x60 cm; Descrição: Caixa de areia pluvial simples; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Caixa de areia pluvial simples

# IfcWasteTerminal: Caixas Inspeção Esgoto Simples (6)
In: Térreo
Type - PredefinedType: FLOORWASTE
Pset_Identificação_Elemento - Rede: Esgoto; Nome: CE- 60x 60cm; Descrição: Caixas Inspeção Esgoto Simples; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Caixas Inspeção Esgoto Simples

# IfcWasteTerminal: Sumidouros, SU1
In: Térreo
Type - PredefinedType: FLOORWASTE
Pset_Identificação_Elemento - Rede: Esgoto; Nome: Circular; Aplicação: Sumidouro; Classe: Unidades de tratamento; Tipo: Sumidouros

# IfcWasteTerminal: Tanques sépticos, TS1
In: Térreo
Type - PredefinedType: FLOORWASTE
Pset_Identificação_Elemento - Rede: Esgoto; Nome: Tanque séptico - concreto; Aplicação: Tanque séptico; Classe: Unidades de tratamento; Tipo: Tanques sépticos
